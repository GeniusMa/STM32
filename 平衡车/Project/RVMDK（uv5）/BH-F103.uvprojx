# Keil uVision project BH-F103.uvprojx, settings and files
target SysTick (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SysTick +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\SysTick;..\..\User\OLED;..\..\User\MPU6050\eMPL;..\..\User\MPU6050;..\..\User\SYSTEM\delay;..\..\User\SYSTEM\sys;..\..\User\SYSTEM\usart;..\..\User\Public\Bit-Band;..\..\User\Public\SystemClock;..\..\User\Public\SysTick-Timer;..\..\User\CONTROL;..\..\User\ENCODER;..\..\User\MOTOR;..\..\User\EXIT;..\..\User\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
  group DOC
    ../../Doc/: readme.txt
  group SYSTEM
    ../../User/SYSTEM/delay/: delay.c
    ../../User/SYSTEM/sys/: sys.c
    ../../User/SYSTEM/usart/: usart.c
  group HAREWARE
    ../../User/MPU6050/: mpu6050.c mpuiic.c
    ../../User/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/OLED/: oled.c
